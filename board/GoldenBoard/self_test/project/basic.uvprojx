# Keil uVision project basic.uvprojx, settings and files
target Basic (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: basic
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx
  c include: ..\..\..\..\mcu\stm32g070\STM32G0xx_HAL_Driver\Inc;..\..\..\..\mcu\stm32g070\STM32G070;..\..\..\..\mcu\stm32g070\CMSIS;..\user;..\..\..\..\eLab\common;..\..\..\..\eLab\elib;..\..\..\..\eLab\3rd\Shell;..\..\..\..\eLab;..\..\..\..\eLab\port\Metal;..\..\..\..\mcu\stm32g070\STM32G0xx_HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group User
    ../user/: main.c bsp.c shell_export.c driver_pwm.c eio_pwm.c app_pwm.c eio_object.c driver_spi.c oled.c eio_pin.c driver_pin.c app_led.c flash.c driver_i2c.c io_ex.c driver_adc.c
  group eLab.common
    ../user/: elab_time.c elab_uart_debug.c
    ../../../../eLab/elib/: elib_queue.c
    ../../../../eLab/common/: elab_export.c elab_common.c
  group eLab.Midware.3rd.Shell
    ../../../../eLab/3rd/Shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group eLab.Test
    ../user/: test_pwm.c
  group MCU
    ../user/: stm32g0xx_it.c system_stm32g0xx.c startup_stm32g070xx.s
  group HAL
    ../../../../mcu/stm32g070/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_ll_adc.c
software components: CMSIS:CORE 5.5.0
