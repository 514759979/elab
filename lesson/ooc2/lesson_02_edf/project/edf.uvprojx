# Keil uVision project edf.uvprojx, settings and files
target Edf (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: basic
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx, __free_rtos__
  c include: ..\..\..\..\mcu\stm32g070\STM32G0xx_HAL_Driver\Inc;..\..\..\..\mcu\stm32g070\STM32G070;..\..\..\..\mcu\stm32g070\CMSIS;..\user;..\..\..\..\elab\port\FreeRTOS;..\..\..\..\elab\3rd\FreeRTOS\portable\RVDS\ARM_CM0;..\..\..\..;..\..\..\..\elab\3rd\FreeRTOS\include;..\user\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group User.App
    ../user/: main.c
    ../user/app/: app.c
  group User.Device
    ../user/device/: oled.c
  group User.Bsp
    ../user/bsp/: bsp.c elab_uart_debug.c
  group User.Export
    ../user/export/: shell_export.c adc_export.c button_export.c pin_export.c i2c_export.c led_export.c pwm_export.c spi_export.c
  group User.Driver
    ../user/driver/: drv_adc_mcu.c drv_button_adc.c drv_button_pin.c drv_pin_i2c.c drv_pin_mcu.c drv_util.c drv_pwm_mcu.c drv_i2c_bus.c drv_spi_bus.c
  group User.test
    ../user/test/: test_oled.c test_self.c
  group Use.Config
    ../user/config/: elab_config.h event_def.h FreeRTOSConfig.h gb_export.h stm32g0xx_hal_conf.h
  group eLab.common
    ../../../../elab/elib/: elib_queue.c
    ../../../../elab/common/: elab_export.c elab_common.c elab_log.c elab_assert.c
  group eLab.edf
    ../../../../elab/edf/: elab_device.c elab_device_null.c
    ../../../../elab/edf/normal/: elab_pin.c elab_pwm.c elab_adc.c elab_spi.c elab_i2c.c elab_rtc.c elab_watchdog.c
    ../../../../elab/edf/user/: elab_button.c elab_led.c
  group eLab.test
    ../../../../elab/test/: test_elog.c test_adc.c test_pwm.c test_pin.c test_rs232.c test_spi.c test_button.c
  group eLab.3rd.Shell
    ../../../../elab/3rd/Shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../user/app/: app.c
  group elab.3rd.FreeRTOS
    ../../../../elab/3rd/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../../../../elab/3rd/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../elab/3rd/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../elab/os/mcu/: cmsis_os2.c
  group elab.3rd.QPC
    ../../../../elab/3rd/qpc/: qpc_export.c
    ../../../../elab/3rd/qpc/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ../../../../elab/3rd/qpc/ports/freertos/: qf_port.c
  group MCU
    ../user/bsp/: stm32g0xx_it.c system_stm32g0xx.c startup_stm32g070xx.s
  group HAL
    ../../../../mcu/stm32g070/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c
software components: CMSIS:CORE 5.5.0
