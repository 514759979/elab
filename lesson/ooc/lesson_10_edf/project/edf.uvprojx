# Keil uVision project edf.uvprojx, settings and files
target Edf (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G070RBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: basic
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G070xx, __free_rtos__
  c include: ..\..\..\..\mcu\stm32g070\STM32G0xx_HAL_Driver\Inc;..\..\..\..\mcu\stm32g070\STM32G070;..\..\..\..\mcu\stm32g070\CMSIS;..\user;..\..\..\..\elab\port\FreeRTOS;..\..\..\..\elab\3rd\FreeRTOS\portable\RVDS\ARM_CM0;..\..\..\..;..\..\..\..\elab\3rd\FreeRTOS\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group User
    ../user/: main.c bsp.c shell_export.c oled.c
  group Driver
    ../../../../board/GoldenBoard/driver/: drv_pin.c drv_pwm.c drv_adc.c drv_spi.c
  group eLab.common
    ../user/: elab_uart_debug.c
    ../../../../elab/elib/: elib_queue.c
    ../../../../elab/common/: elab_export.c elab_common.c elab_log.c elab_assert.c
  group eLab.Midware.3rd.Shell
    ../../../../elab/3rd/Shell/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
  group eLab.midware
    ../../../../elab/midware/ebutton/: ebutton.c
  group eLab.edf
    ../../../../elab/edf/: elab_device.c elab_device_null.c
    ../../../../elab/edf/normal/: elab_pin.c elab_pwm.c elab_adc.c elab_spi.c elab_i2c.c elab_rtc.c elab_watchdog.c
  group eLab.test
    ../../../../board/GoldenBoard/test/: test_led.c test_pwm.c test_adc.c
    ../../../../elab/test/: test_elog.c
    ../user/: test_oled.c
  group elab.3rd.FreeRTOS
    ../../../../elab/3rd/FreeRTOS/portable/RVDS/ARM_CM0/: port.c
    ../../../../elab/3rd/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../elab/3rd/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../../elab/os/mcu/: cmsis_os2.c
  group MCU
    ../user/: stm32g0xx_it.c system_stm32g0xx.c startup_stm32g070xx.s
  group HAL
    ../../../../mcu/stm32g070/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_cortex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c
software components: CMSIS:CORE 5.5.0
